** amplificar diferencial com resistores de emissor **

* impoe acout = 0 tal que o HSPICE calcula vdb(x, y) com uma
* magnitude de diferencas e nao uma diferenca de magnitudes
.option post acout=0

** descricao do circuito **
* fontes de alimentacao
Vcc 1 0 DC +10V
* sinal de entrada
Vs 6 0 AC 1V
Rs 6 5 5k
* par diferencial
Rc1 1 2 10k
Rc2 1 3 10k
Q1 3 5 7 Q2N3904
Q2 2 77 8 Q2N3904
Rs2 77 0 5k
* resistores de emissor
* resistencia zero
Re1 7 4 0.00001
Re2 8 4 0.00001
* corrente de polarizacao
Ibias 4 0 1mA

* modelo 2N3904
.model1 Q2N3904 NPN (Is=6.734f Xti=3 Eg=1.11 Vaf=74.03 Bf=416.4 Ne=1.259
+ Ise=6.734f Ikf=66.78m Xtb=1.5 Br=.7371 Nc=2 Isc=0 Ikr=0 Rc=1
+ Cjc=3.638p Mjc=.3085 Vjc=.75 Fc=.5 Cje=4.493p Mje=.2593
+ Vje=.75 Tr=239.5n Tf=301.2p Itf=.4 Vtf=4 Xtf=2 Rb=10)
